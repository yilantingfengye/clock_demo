# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CX32L003F8 XMC
  pack: XMC.CX32L003_DFP.1.0.7
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER
  c include: ..\Inc;..\Drivers\CMSIS\Device\XMC\CX32L003\Source;..\Drivers\CMSIS\Device\XMC\CX32L003\Include;..\Drivers\CX32L003_HAL_Driver\Inc;..\Drivers\BSP\CX32L003_StarterKit;..\Drivers\CMSIS\Include;..\Common;..\Drivers\BSP\OLED;..\Drivers\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Drivers/BSP/CX32L003_StarterKit
    ../Drivers/BSP/CX32L003_StarterKit/: cx32l003_starterkit.c
    ../Drivers/BSP/OLED/: bmp.h oled.c oled.h oledfont.h
    ../Drivers/BSP/: key.c key.h beep.c beep.h DS1302Z.c DS1302Z.h
  group Drivers/CX32L0xx_HAL_Driver
    ../Drivers/CX32L003_HAL_Driver/Src/: cx32l003_hal.c cx32l003_hal_adc.c cx32l003_hal_awk.c cx32l003_hal_basetim.c cx32l003_hal_beep.c cx32l003_hal_clktrim.c cx32l003_hal_cortex.c cx32l003_hal_crc.c cx32l003_hal_flash.c cx32l003_hal_gpio.c cx32l003_hal_i2c.c cx32l003_hal_iwdg.c cx32l003_hal_lptim.c cx32l003_hal_lpuart.c cx32l003_hal_lvd.c cx32l003_hal_owire.c cx32l003_hal_pca.c cx32l003_hal_pwr.c cx32l003_hal_rcc.c cx32l003_hal_rtc.c cx32l003_hal_spi.c cx32l003_hal_tim.c cx32l003_hal_uart.c cx32l003_hal_vc.c cx32l003_hal_wwdg.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/XMC/CX32L003/Source/ARM/: startup_cx32l003.s
  group Application/User
    ../Src/: main.c cx32l003_hal_msp.c cx32l003_it.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/XMC/CX32L003/Source/: system_cx32l003.c
  group Common
    ../Common/: util.c log.c
  group Doc
    ../: readme.txt
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CX32L003F8 XMC
  pack: XMC.CX32L003_DFP.1.0.7
  cpu: as above
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,_debug_
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
